# Keil uVision project USBD_CUSTOM_HID_Keyboard.uvprojx, settings and files
target APM32E103 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32E103ZE Geehy
  pack: Geehy.APM32E1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USBD_CUSTOM_HID_Keyboard
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: APM32E10X_HD,USB_DEVICE,APM32E103_EVAL
  c include: ..\..\..\..\..\..\..\Boards;..\..\..\..\..\..\..\Boards\Board_APM32E103_EVAL\inc;..\..\..\..\..\..\..\Libraries\APM32E10x_StdPeriphDriver\inc;..\..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\..\Libraries\Device\Geehy\APM32E10x\Include;..\..\..\..\..\..\..\Middlewares\USB_Library\Device\Class\CustomHID\Inc;..\..\..\..\..\..\..\Middlewares\USB_Library\Device\Core\Inc;..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group App/Bsp
    ../../../../../../../Boards/: Board.c
    ../../../../../../../Boards/Board_APM32E103_EVAL/src/: bsp_delay.c
  group App/User
    ../../Source/: main.c apm32e10x_int.c
  group App/User/USB_DEV/App
    ../../Source/: usb_device_user.c usbd_custom_hid_if.c usbd_descriptor.c
  group App/User/USB_DEV/Config
    ../../Source/: usbd_board.c
  group Libraries/CMSIS
    ../../Source/: system_apm32e10x.c
    ./: startup_apm32e10x_hd.s
  group Libraries/APM32E10x_Std_Driver
    ../../../../../../../Libraries/APM32E10x_StdPeriphDriver/src/: apm32e10x_adc.c apm32e10x_bakpr.c apm32e10x_can.c apm32e10x_crc.c apm32e10x_dac.c apm32e10x_dbgmcu.c apm32e10x_dma.c apm32e10x_dmc.c apm32e10x_eint.c apm32e10x_fmc.c apm32e10x_gpio.c apm32e10x_i2c.c apm32e10x_iwdt.c apm32e10x_misc.c apm32e10x_pmu.c apm32e10x_rcm.c apm32e10x_rtc.c apm32e10x_sci2c.c apm32e10x_sdio.c apm32e10x_smc.c apm32e10x_spi.c apm32e10x_tmr.c apm32e10x_usart.c apm32e10x_usb.c apm32e10x_usb_device.c apm32e10x_wwdt.c
  group Middlewares/USB_Device_Library
    ../../../../../../../Middlewares/USB_Library/Device/Core/Src/: usbd_core.c usbd_dataXfer.c usbd_stdReq.c
  group Middlewares/USB_Device_Library/Class
    ../../../../../../../Middlewares/USB_Library/Device/Class/CustomHID/Src/: usbd_customhid.c
  group Document
    ../../: readme.txt
