<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\SCI2C_TwoBoards_SlaveReceiver.ewp</path>
    </project>
    <batchBuild />
</workspace>
