<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\EINT_Config.ewp</path>
    </project>
    <batchBuild />
</workspace>
