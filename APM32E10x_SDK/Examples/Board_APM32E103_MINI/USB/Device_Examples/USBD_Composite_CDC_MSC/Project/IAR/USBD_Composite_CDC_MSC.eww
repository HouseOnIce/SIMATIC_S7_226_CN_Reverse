<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\USBD_Composite_CDC_MSC.ewp</path>
    </project>
    <batchBuild />
</workspace>
