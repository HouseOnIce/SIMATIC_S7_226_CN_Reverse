# IAR project CMSIS_RTX.ewp, settings and files
configuration APM32E103 (ARM, debug)
  General.OGChipSelectEditMenu: APM32E103ZE Geehy APM32E103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: APM32E103_MINI
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Libraries\APM32E10x_StdPeriphDriver\inc; ..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32E10x\Include; ..\..\..\..\..\..\Boards; ..\..\..\..\..\..\Boards\Board_APM32E103_MINI\inc; ..\..\Include; ..\..\RTOS2; ..\..\..\..\..\..\Libraries\CMSIS\RTOS2\Source; ..\..\..\..\..\..\Libraries\CMSIS\RTOS2\Include; ..\..\..\..\..\..\Libraries\CMSIS\RTOS2\RTX\Include; ..\..\..\..\..\..\Libraries\CMSIS\RTOS2\RTX\Include1
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: CMSIS_RTX.srec
  ILINK.IlinkOutputFile: CMSIS_RTX.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../Source/: apm32e10x_int.c main.c
  group Boards
    ../../../../../../Boards/: Board.c
    ../../../../../../Boards/Board_APM32E103_MINI/src/: bsp_delay.c
  group CMSIS
    ../../../../../../Libraries/Device/Geehy/APM32E10x/Source/iar/: startup_apm32e10x_hd.s
    ../../Source/: system_apm32e10x.c
  group Document
    ../../: readme.txt
  group RTOS2
    ../../../../../../Libraries/CMSIS/RTOS2/RTX/Source/IAR/: irq_armv7m.s
    ../../../../../../Libraries/CMSIS/RTOS2/Source/: os_systick.c
    ../../RTOS2/: RTX_Config.c
    ../../../../../../Libraries/CMSIS/RTOS2/RTX/Source/: rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
  group StdPeriphDriver
    ../../../../../../Libraries/APM32E10x_StdPeriphDriver/src/: apm32e10x_adc.c apm32e10x_bakpr.c apm32e10x_can.c apm32e10x_crc.c apm32e10x_dac.c apm32e10x_dbgmcu.c apm32e10x_dma.c apm32e10x_dmc.c apm32e10x_eint.c apm32e10x_fmc.c apm32e10x_gpio.c apm32e10x_i2c.c apm32e10x_iwdt.c apm32e10x_misc.c apm32e10x_pmu.c apm32e10x_rcm.c apm32e10x_rtc.c apm32e10x_sci2c.c apm32e10x_sdio.c apm32e10x_smc.c apm32e10x_spi.c apm32e10x_tmr.c apm32e10x_usart.c apm32e10x_usb.c apm32e10x_wwdt.c
