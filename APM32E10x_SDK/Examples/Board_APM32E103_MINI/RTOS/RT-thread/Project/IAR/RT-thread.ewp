# IAR project RT-thread.ewp, settings and files
configuration APM32E103 (ARM, debug)
  General.OGChipSelectEditMenu: APM32E103ZE Geehy APM32E103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: APM32E103_MINI
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Libraries\APM32E10x_StdPeriphDriver\inc; ..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32E10x\Include; ..\..\..\..\..\..\Boards; ..\..\..\..\..\..\Boards\Board_APM32E103_MINI\inc; ..\..\Include; ..\..\..\..\..\..\Middlewares\RTThread\rtthread-nano-master\rt-thread\include; ..\..\..\..\..\..\Middlewares\RTThread\rtthread-nano-master\rt-thread\components\finsh
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RT-thread.srec
  ILINK.IlinkOutputFile: RT-thread.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../Source/: apm32e10x_int.c main.c
  group Boards
    ../../../../../../Boards/: Board.c
    ../../../../../../Boards/Board_APM32E103_MINI/src/: bsp_delay.c
  group CMSIS
    ../../../../../../Libraries/Device/Geehy/APM32E10x/Source/iar/: startup_apm32e10x_hd.s
    ../../Source/: system_apm32e10x.c
  group Document
    ../../: readme.txt
  group Finish
    ../../../../../../Middlewares/RTThread/rtthread-nano-master/rt-thread/components/finsh/: cmd.c msh.c shell.c
    ../../Source/: finsh_port.c
  group Middleware/RT-Thread
    ../../../../../../Middlewares/RTThread/rtthread-nano-master/rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../../../../../../Middlewares/RTThread/rtthread-nano-master/rt-thread/libcpu/arm/cortex-m3/: context_iar.S cpuport.c
    ../../Source/: rtthread_board.c
  group StdPeriphDriver
    ../../../../../../Libraries/APM32E10x_StdPeriphDriver/src/: apm32e10x_adc.c apm32e10x_bakpr.c apm32e10x_can.c apm32e10x_crc.c apm32e10x_dac.c apm32e10x_dbgmcu.c apm32e10x_dma.c apm32e10x_dmc.c apm32e10x_eint.c apm32e10x_fmc.c apm32e10x_gpio.c apm32e10x_i2c.c apm32e10x_iwdt.c apm32e10x_misc.c apm32e10x_pmu.c apm32e10x_rcm.c apm32e10x_rtc.c apm32e10x_sci2c.c apm32e10x_sdio.c apm32e10x_smc.c apm32e10x_spi.c apm32e10x_tmr.c apm32e10x_usart.c apm32e10x_usb.c apm32e10x_wwdt.c
